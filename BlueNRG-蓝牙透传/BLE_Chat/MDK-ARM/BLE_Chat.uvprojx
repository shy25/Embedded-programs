# Keil uVision project BLE_Chat.uvprojx, settings and files
target Client (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: BLE_Chat_Client +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH CLIENT=1
  c include: ..\inc;..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\Library\CMSIS\Include;..\..\Library\hal\inc;..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\Library\Bluetooth_LE\inc;..\..\Library\Bluetooth_LE\OTA\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  group BlueNRG1_Periph_Driver
    ../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_uart.c BlueNRG1_crmu.c BlueNRG1_gpio.c misc.c BlueNRG1_flash.c BlueNRG1_wdg.c BlueNRG1_rng.c
  group Platforms_Layers
    ../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Config.c SDK_EVAL_Com.c
  group Startup
    ../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../src/: BLE_Chat_main.c chat.c gatt_db.c BlueNRG1_it.c para_center.c para_unit.c comm.c
    ../../Library/hal/src/: osal.c
  group Hal
    ../../Library/hal/src/: context_switch.s clock.c gp_timer.c sleep.c
  group Stack
    ../../Library/Bluetooth_LE/library/: bluenrg1_stack_lib_0_9_keil.lib
target Server (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x28000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_Chat_Server +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_INTERNAL_RO SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1  USE_FULL_ASSERT
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
target Server_LowerApp_OTA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: BLE_Chat_Server_LowerApp_OTA +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1 ST_OTA_LOWER_APPLICATION=1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --predefine="-DST_OTA_LOWER_APPLICATION=1"
target Server_HigherApp_OTA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: BLE_Chat_Server_HigherApp_OTA +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1 ST_OTA_HIGHER_APPLICATION=1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --predefine="-DST_OTA_HIGHER_APPLICATION=1"
target Server_Use_OTA_ServiceManager (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: BLE_Chat_Server_Use_OTA_ServiceManager +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1 ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --predefine="-DST_USE_OTA_SERVICE_MANAGER_APPLICATION=1"
